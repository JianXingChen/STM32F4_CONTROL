# Keil uVision project F405RGT6.uvproj, settings and files
target STM32F407 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: F405RGT6 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM4
  c include: ..\Core;..\User;..\Lib\inc;..\System;..\DMP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: main.c system_stm32f4xx.c clock.c Prepare_data.c holder.c speed_control.c HMC5883L.c
  group Core
    ../Core/: startup_stm32f40_41xxx.s
  group Lib
    ../Lib/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c
  group Debug
    ./: USART3.c
  group Sensor
    ./: I2C.c 6050.c
  group Systerm
    ./: delay.c sys.c
  group IMU
    ./: Imu.c
